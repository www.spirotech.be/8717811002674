Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_HC250F_INT-EN.ifc
Time: 2025-08-05T18:24:54+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1964073_1
Port_1964073_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_INT-EN:HC250F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_INT-EN:HC250F:1964073
In: F00
Type - Material: Color RGB 128-128-128, Color RGB 198-000-000, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Body Radius: 254 mm; Connection Diameter: 250 mm; Diameter: 508 mm; Dist A: 136.5 mm; Dist B: 3 mm; Dist C: 23 mm; Dist D: 132.9 mm; Drain1 Visibility: no; Drain2 Visibility: yes; End: no; End Distance: 74 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_INT-EN; Geometry Radius: 101.6 mm; Handle Offset: 408 mm; H Total: 2836 mm; Radius A: 202.5 mm; Radius B: 160 mm; Rings: yes; Rings Distance: 269 mm; Rings Height: 748 mm; Rings Offset: 25 mm; Ring Visibility: yes; Valve Distance: 2546 mm; With Flanges: yes
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 250 mm; Connection Outer Diameter: 273 mm; H: 2672 mm; h1: 1448 mm; L: 750 mm; LF: 890 mm; Use Nominal Diameter: yes
Type - General - Annual Maintenance: Drain dirt from unit
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Flange DN250 - High-Flow; Article Type: HC250F; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Flange DN250 - High-Flow; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811002773; Manufacturer: Spirotech; Manufacturer Art. No.: HC250F; Manufacturer URL: https://www.spirotech.com/8717811002773; MEPcontent Class: SEPARATOR_AIR AND DIRT; Model: HC250F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: HC250F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Air Vent: Color RGB 168-128-048; Drain Body: Color RGB 128-128-128; Drain Handle: Color RGB 198-000-000; Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.32111 m3/s; K Coefficient: 0; Pressure Stage: PN16
Type - Mechanical - Flow - Kv: 0.32111 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: HC250F; sets with these values: 2
Other - Connector Offset: 445 mm; Connector Offset Total: 890 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi HC_INT-EN: HC250F; Type: HC250F; Type Id: 1964026
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 250 mm; Minimum Size: 250 mm; Volume: 0.535578 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
